<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\CC2530-Serial.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
    </batchDefinition>
  </batchBuild>
</workspace>
